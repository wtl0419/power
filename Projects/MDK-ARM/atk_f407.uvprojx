# Keil uVision project atk_f407.uvprojx, settings and files
target lwIP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --locale=english
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Middlewares\lwip\src\include;..\..\Middlewares\lwip\src\include\lwip;..\..\Middlewares\lwip\arch;..\..\Middlewares\lwip\lwip_app;..\..\Middlewares\lwip;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\Drivers\BSP\CAN;..\..\Drivers\BSP\TOUCH;..\..\Common;..\..\Drivers\BSP\LCD;..\..\Drivers\BSP\74HC595;..\..\Drivers\BSP\SP9316;..\..\Drivers\BSP\ADC;..\..\Drivers\BSP\74HC165;..\..\Drivers\BSP\USART5;..\..\Drivers\BSP\HMI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c freertos_demo.c app_global.c app_current.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_eth.c stm32f4xx_hal_can.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/SRAM/: sram.c
    ../../Drivers/BSP/ETHERNET/: ethernet.c
    ../../Drivers/BSP/CAN/: can.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/TOUCH/: ft5426.c touch.c xpt2046.c
    ../../Drivers/BSP/TIMER/: btim.c
    ../../Drivers/BSP/74HC595/: bsp_hc595.c
    ../../Drivers/BSP/SP9316/: bsp_sp9316.c
    ../../Drivers/BSP/ADC/: bsp_adc.c
    ../../Drivers/BSP/74HC165/: bsp_hc165.c
    ../../Drivers/BSP/HMI/: bsp_hmi.c
    ../../Drivers/BSP/USART5/: bsp_usart5.c
  group Middlewares/USMART
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/lwip/src/api
    ../../Middlewares/LWIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/lwip/src/core
    ../../Middlewares/LWIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Middlewares/LWIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/lwip/src/netif
    ../../Middlewares/LWIP/src/netif/: ethernet.c
  group Middlewares/lwip/arch
    ../../Middlewares/LWIP/arch/: ethernetif.c lwip_comm.c sys_arch.c
  group Middlewares/lwip/lwip_app
    ../../Middlewares/lwip/lwip_app/: lwip_demo.c
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Readme
    ../../: readme.txt
  group Common
    ../../Common/: common.c
